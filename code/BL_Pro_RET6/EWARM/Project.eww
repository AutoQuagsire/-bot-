<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\BL_Pro_RET6.ewp</path>
  </project>
  <batchBuild />
</workspace>
